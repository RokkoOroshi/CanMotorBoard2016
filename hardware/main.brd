# Repository RokkoOroshi/CanMotorBoard2016

File ReadMe.md:

# CAN Motor Driver Board

can通信機能対応2chモータドライバ基板

## IO

- DCモータ2ch制御 avg3.0A,peek4.5A (TA8429H使用)(放熱してないので無理です..)
- モータ電源ポート2個
- CAN通信ポート2個
- avr ISP 書き込みポート
- Arduino書き込み対応シリアル通信ポート
- 汎用入出力4ch(内2chはプルダウン済み)
- アナログ入力2ch
- 状態表示用LED 2ch

## 製作動機

- 製作負担軽減（と個人的な趣好）のために既存のユニバーサル基板からプリント基板への移行したい
- 配線の簡略化、基板との双方向通信実現のためにCAN通信を導入したい

## 製作時の配慮
- ストックが多数あるTA8429Hを使う
- PWM入力に対応し、今までと同じ方法でも使用できるようにする
- Arduino開発環境に対応し、初心者でも扱いやすいように

## License

- MIT

## 使用ライブラリ等

- CAN_BUS_Shield : MIT : https://github.com/Seeed-Studio/CAN_BUS_Shield
- MsTimer2 : LGPL : http://playground.arduino.cc/Main/MsTimer2
- pins_arduino.h : LGPL
- Arduino-SerialCommand : ? : https://github.com/kroimon/Arduino-SerialCommand

## EAGLE design hardware/main.brd

Parts:
5VLED: LED2012
BAT1, BAT2: B2P-VH
BATLED: LED2012
C1, C2: 0.1uF; SMD2012
C3, C4, C5, C6: 22uF; SMD2012
CN3, CN4: B4B-PH-K-S
CON1: B6B-ZR
CON2: B4B-ZR
D1: DIODESOD123; SOD-123
IC1: MEGA168; TQFP32-08
IC4: MCP2551; SOIC
IC5, IC6: ACS712; SO08
IC7, IC8: TA8429H
INPUT1, INPUT2: PINHD-2X3; 2X03
JUMP: 0; SMD2012
M1, M2: B2P-VH
M1LED1, M1LED2, M2LED1, M2LED2: LED2012
PWMIN: PINHD-2X3; 2X03
Q1, Q2: 16MHz; HC49/S
R1, R3, R4, R5, R6, R7, R9, R10, R11: 1k; SMD2012
R2, R8: 10k; SMD2012
R14, R15: 2.2k; SMD2012
STAT1, STAT2: LED2012
U$1: MCP2515SO; SO18L

Connections:
+5V: 5VLED.A, C2.1, CN3.1, CN4.1, CON1.2, D1.C, IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), IC4.3 (VCC), IC5.8 (VCC), IC6.8 (VCC), IC7.P$11 (VCC), IC7.P$12 (ST), IC8.P$11 (VCC), IC8.P$12 (ST), INPUT1.3, INPUT1.4, INPUT2.3, INPUT2.4, R2.1, R8.2, U$1.18 (VCC)
+7V: BAT1.1, BAT2.1, BATLED.A, IC7.P$10 (VS), IC8.P$10 (VS), R14.2
BAT-SENS: IC1.25 (PC2(ADC2/PCINT10)), R14.1, R15.2
CS: IC1.12 (PB0(ICP1/CLKO/PCINT0)), U$1.16 (CS/)
DRT: C1.2, CON2.1
GND: C2.2, C3.1, C4.1, C5.2, C6.2, CN3.2, CN4.2, CON1.6, CON2.4, IC1.3 (GND), IC1.5 (GND), IC1.21 (AGND), IC4.2 (GND), IC5.5 (GND), IC6.5 (GND), INPUT1.5, INPUT1.6, INPUT2.5, INPUT2.6, JUMP.1, PWMIN.5, PWMIN.6, R1.2, R4.1, R6.1, R7.1, R9.1, R11.2, R15.1, U$1.9 (GND)
INPUT1-1: IC1.26 (PC3(ADC3/PCINT11)), INPUT1.1
INPUT1-2: IC1.27 (PC4(ADC4/SDA/PCINT12)), INPUT1.2
INPUT2-1: IC1.22 (ADC7), INPUT2.1
INPUT2-2: IC1.19 (ADC6), INPUT2.2
INT: IC1.32 (PD2(INT0/PCINT18)), U$1.12 (INT/)
M1-SENS: IC1.23 (PC0(ADC0/PCINT8)), IC6.7 (VOUT)
M1IN1: IC1.13 (PB1(OC1A/PCINT1)), IC7.P$1 (IN1)
M1IN2: IC1.14 (PB2(SS/OC1B/PCINT2)), IC7.P$2 (IN2)
M2-SENS: IC1.24 (PC1(ADC1/PCINT9)), IC5.7 (VOUT)
M2IN1: IC1.9 (PD5(T1/OC0B/PCINT21)), IC8.P$1 (IN1)
M2IN2: IC1.10 (PD6(AIN0/OC0A/PCINT22)), IC8.P$2 (IN2)
MGND: BAT1.2, BAT2.2, IC7.P$6 (GND), IC8.P$6 (GND), JUMP.2, R10.1
unnamed: C3.2, IC1.7 (PB6(XTAL1/TOSC1/PCINT6)), Q1.2
unnamed: C4.2, IC1.8 (PB7(XTAL2/TOSC2/PCINT7)), Q1.1
unnamed: IC8.P$4 (OUT1), M2.2, R3.1
unnamed: IC6.1 (I+_0), IC6.2 (I+_1), M1.1, M1LED1.A, M1LED2.K
unnamed: D1.A, PWMIN.3, PWMIN.4
unnamed: IC5.1 (I+_0), IC5.2 (I+_1), M2.1, M2LED1.A, M2LED2.K
unnamed: IC4.1 (TXD), U$1.1 (TXCAN)
unnamed: IC4.4 (RXD), U$1.2 (RXCAN)
unnamed: 5VLED.K, R6.2
unnamed: R1.1, STAT2.K
unnamed: CN3.4, CN4.4, IC4.6 (CANL)
unnamed: CN3.3, CN4.3, IC4.7 (CANH)
unnamed: M1LED1.K, M1LED2.A, R5.2
unnamed: IC7.P$4 (OUT1), M1.2, R5.1
unnamed: R2.2, U$1.17 (RESET/)
unnamed: M2LED1.K, M2LED2.A, R3.2
unnamed: C6.1, Q2.1, U$1.7 (OSC2)
unnamed: BATLED.K, R10.2
unnamed: IC6.3 (I-_0), IC6.4 (I-_1), IC7.P$8 (OUT2)
unnamed: IC5.3 (I-_0), IC5.4 (I-_1), IC8.P$8 (OUT2)
unnamed: C5.1, Q2.2, U$1.8 (OSC1)
unnamed: IC4.8 (RS), R4.2
unnamed: R11.1, STAT1.K
PWMIN1: IC1.11 (PD7(AIN1/PCINT23)), PWMIN.1, R9.2
PWMIN2: IC1.28 (PC5(ADC5/SCL/PCINT13)), PWMIN.2, R7.2
RESET: C1.1, CON1.1, IC1.29 (PC6(/RESET/PCINT14)), R8.1
RX: CON2.2, IC1.30 (PD0(RXD/PCINT16))
SCK: CON1.3, IC1.17 (PB5(SCK/PCINT5)), U$1.13 (SCK)
SI: CON1.5, IC1.15 (PB3(MOSI/OC2A/PCINT3)), U$1.14 (SI)
SO: CON1.4, IC1.16 (PB4(MISO/PCINT4)), U$1.15 (SO)
STAT-LED1: IC1.1 (PD3(INT1/OC2B/PCINT19)), STAT1.A
STAT-LED2: IC1.2 (PD4(T0/XCK/PCINT20)), STAT2.A
TX: CON2.3, IC1.31 (PD1(TXD/PCINT17))

Notes on the sheet:
Limit Switch and Analog Input
Writer
CAN通信対応モータドライバ ver 1 .1
Battery
Motor Driver
CAN Communication
Connector
GND Bridge
Battery Voltage Sens
Battery LED
Serial & Arduino
Pwm In
v1.0から変更 INPUT2-1とPWMIN2を入れ替え

Board: 2 copper layers, 50.0 x 50.0 mm, 49 parts (16 on the bottom side), 51 nets.

## Code that names these connections

File firmware/hardware_profile.h:

#ifndef HARDWARE_PROFILE_H
#define HARDWARE_PROFILE_H

/*
  Arduino - AVR
  ---------
  D0  - PD0
  D1  - PD1
  D2  - PD2
  D3  - PD3
  D4  - PD4
  D5  - PD5
  D6  - PD6
  D7  - PD7
  ---------
  D8  - PB0
  D9  - PB1
  D10 - PB2
  D11 - PB3
  D12 - PB4
  D13 - PB5
  ---------
  A0  - PC0
  A1  - PC1
  A2  - PC2
  A3  - PC3
  A4  - PC4
  A5  - PC5
  (32pin Only)
  A6  - ADC6
  A7  - ADC7
 */

// Digital Pin
static const uint8_t SPI_CS   =  8;
static const uint8_t SPI_MOSI = 11;
static const uint8_t SPI_MISO = 12;
static const uint8_t SPI_SCK  = 13;

static const uint8_t CAN_INT  =  2;
static const uint8_t CAN_CS   =  8;
static const uint8_t CAN_MOSI = 11;
static const uint8_t CAN_MISO = 12;
static const uint8_t CAN_SCK  = 13;

static const uint8_t RX       =  0;
static const uint8_t TX       =  1;

static const uint8_t STAT_LED1=  3;
static const uint8_t STAT_LED2=  4;

static const uint8_t M1IN1    =  9;
static const uint8_t M1IN2    = 10;
static const uint8_t M2IN1    =  5;
static const uint8_t M2IN2    =  6;

static const uint8_t PWMIN1   =  7;
static const uint8_t PWMIN2   = 19;

// Analog
static const uint8_t M1_SENS  = 14; // A0
static const uint8_t M2_SENS  = 15; // A1
static const uint8_t BAT_SENS = 16; // A2

static const uint8_t INPUT1_1 = 17;
static const uint8_t INPUT1_2 = 18;

static const uint8_t INPUT2_1 = 21; // A7
static const uint8_t INPUT2_2 = 20; // A6

#endif

File firmware/RokkoOroshiCanMotorBoard/avr/variants/can_md_standard/pins_arduino_standard.h:

/*
  pins_arduino.h - Pin definition functions for Arduino
  Part of Arduino - http://www.arduino.cc/

  Copyright (c) 2007 David A. Mellis

  This library is free software; you can redistribute it and/or
  modify it under the terms of the GNU Lesser General Public
  License as published by the Free Software Foundation; either
  version 2.1 of the License, or (at your option) any later version.

  This library is distributed in the hope that it will be useful,
  but WITHOUT ANY WARRANTY; without even the implied warranty of
  MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the GNU
  Lesser General Public License for more details.

  You should have received a copy of the GNU Lesser General
  Public License along with this library; if not, write to the
  Free Software Foundation, Inc., 59 Temple Place, Suite 330,
  Boston, MA  02111-1307  USA

  $Id: wiring.h 249 2007-02-03 16:52:51Z mellis $
*/

#ifndef Pins_Arduino_Standard_h
#define Pins_Arduino_Standard_h

#include <avr/pgmspace.h>

#define NUM_DIGITAL_PINS            20
#define NUM_ANALOG_INPUTS           6
#define analogInputToDigitalPin(p)  ((p < 6) ? (p) + 14 : -1)

#if defined(__AVR_ATmega8__)
#define digitalPinHasPWM(p)         ((p) == 9 || (p) == 10 || (p) == 11)
#else
#define digitalPinHasPWM(p)         ((p) == 3 || (p) == 5 || (p) == 6 || (p) == 9 || (p) == 10 || (p) == 11)
#endif

static const uint8_t SS   = 10;
static const uint8_t MOSI = 11;
static const uint8_t MISO = 12;
static const uint8_t SCK  = 13;

static const uint8_t SDA = 18;
static const uint8_t SCL = 19;
#define LED_BUILTIN 13

static const uint8_t A0 = 14;
static const uint8_t A1 = 15;
static const uint8_t A2 = 16;
static const uint8_t A3 = 17;
static const uint8_t A4 = 18;
static const uint8_t A5 = 19;
static const uint8_t A6 = 20;
static const uint8_t A7 = 21;

#define digitalPinToPCICR(p)    (((p) >= 0 && (p) <= 21) ? (&PCICR) : ((uint8_t *)0))
#define digitalPinToPCICRbit(p) (((p) <= 7) ? 2 : (((p) <= 13) ? 0 : 1))
#define digitalPinToPCMSK(p)    (((p) <= 7) ? (&PCMSK2) : (((p) <= 13) ? (&PCMSK0) : (((p) <= 21) ? (&PCMSK1) : ((uint8_t *)0))))
#define digitalPinToPCMSKbit(p) (((p) <= 7) ? (p) : (((p) <= 13) ? ((p) - 8) : ((p) - 14)))

#define digitalPinToInterrupt(p)  ((p) == 2 ? 0 : ((p) == 3 ? 1 : NOT_AN_INTERRUPT))

#ifdef ARDUINO_MAIN

// On the Arduino board, digital pins are also used
// for the analog output (software PWM).  Analog input
// pins are a separate set.

// ATMEL ATMEGA8 & 168 / ARDUINO
//
//                  +-\/-+
//            PC6  1|    |28  PC5 (AI 5)
//      (D 0) PD0  2|    |27  PC4 (AI 4)
//      (D 1) PD1  3|    |26  PC3 (AI 3)
//      (D 2) PD2  4|    |25  PC2 (AI 2)
// PWM+ (D 3) PD3  5|    |24  PC1 (AI 1)
//      (D 4) PD4  6|    |23  PC0 (AI 0)
//            VCC  7|    |22  GND
//            GND  8|    |21  AREF
//            PB6  9|    |20  AVCC
//            PB7 10|    |19  PB5 (D 13)
// PWM+ (D 5) PD5 11|    |18  PB4 (D 12)
// PWM+ (D 6) PD6 12|    |17  PB3 (D 11) PWM
//      (D 7) PD7 13|    |16  PB2 (D 10) PWM
//      (D 8) PB0 14|    |15  PB1 (D 9) PWM
//                  +----+
//
// (PWM+ indicates the additional PWM pins on the ATmega168.)

// ATMEL ATMEGA1280 / ARDUINO
//
// 0-7 PE0-PE7   works
// 8-13 PB0-PB5  works
// 14-21 PA0-PA7 works 
// 22-29 PH0-PH7 works
// 30-35 PG5-PG0 works
// 36-43 PC7-PC0 works
// 44-51 PJ7-PJ0 works
// 52-59 PL7-PL0 works
// 60-67 PD7-PD0 works
// A0-A7 PF0-PF7
// A8-A15 PK0-PK7

// these arrays map port names (e.g. port B) to the
// appropriate addresses for various functions (e.g. reading
// and writing)
const uint16_t PROGMEM port_to_mode_PGM[] = {
	NOT_A_PORT,
	NOT_A_PORT,
	(uint16_t) &DDRB,
	(uint16_t) &DDRC,
	(uint16_t) &DDRD,
};

const uint16_t PROGMEM port_to_output_PGM[] = {
	NOT_A_PORT,
	NOT_A_PORT,
	(uint16_t) &PORTB,
	(uint16_t) &PORTC,
	(uint16_t) &PORTD,
};

const uint16_t PROGMEM port_to_input_PGM[] = {
	NOT_A_PORT,
	NOT_A_PORT,
	(uint16_t) &PINB,
	(uint16_t) &PINC,
	(uint16_t) &PIND,
};

const uint8_t PROGMEM digital_pin_to_port_PGM[] = {
	PD, /* 0 */
	PD,
	PD,
	PD,
	PD,
	PD,
	PD,
	PD,
	PB, /* 8 */
	PB,
	PB,
	PB,
	PB,
	PB,
	PC, /* 14 */
	PC,
	PC,
	PC,
	PC,
	PC,
};

const uint8_t PROGMEM digital_pin_to_bit_mask_PGM[] = {
	_BV(0), /* 0, port D */
	_BV(1),
	_BV(2),
	_BV(3),
	_BV(4),
	_BV(5),
	_BV(6),
	_BV(7),
	_BV(0), /* 8, port B */
	_BV(1),
	_BV(2),
	_BV(3),
	_BV(4),
	_BV(5),
	_BV(0), /* 14, port C */
	_BV(1),
	_BV(2),
	_BV(3),
	_BV(4),
	_BV(5),
};

const uint8_t PROGMEM digital_pin_to_timer_PGM[] = {
	NOT_ON_TIMER, /* 0 - port D */
	NOT_ON_TIMER,
	NOT_ON_TIMER,
	// on the ATmega168, digital pin 3 has hardware pwm
#if defined(__AVR_ATmega8__)
	NOT_ON_TIMER,
#else
	TIMER2B,
#endif
	NOT_ON_TIMER,
	// on the ATmega168, digital pins 5 and 6 have hardware pwm
#if defined(__AVR_ATmega8__)
	NOT_ON_TIMER,
	NOT_ON_TIMER,
#else
	TIMER0B,
	TIMER0A,
#endif
	NOT_ON_TIMER,
	NOT_ON_TIMER, /* 8 - port B */
	TIMER1A,
	TIMER1B,
#if defined(__AVR_ATmega8__)
	TIMER2,
#else
	TIMER2A,
#endif
	NOT_ON_TIMER,
	NOT_ON_TIMER,
	NOT_ON_TIMER,
	NOT_ON_TIMER, /* 14 - port C */
	NOT_ON_TIMER,
	NOT_ON_TIMER,
	NOT_ON_TIMER,
	NOT_ON_TIMER,
};

#endif

// These serial port names are intended to allow libraries and architecture-neutral
// sketches to automatically default to the correct port name for a particular type
// of use.  For example, a GPS module would normally connect to SERIAL_PORT_HARDWARE_OPEN,
// the first hardware serial port whose RX/TX pins are not dedicated to another use.
//
// SERIAL_PORT_MONITOR        Port which normally prints to the Arduino Serial Monitor
//
// SERIAL_PORT_USBVIRTUAL     Port which is USB virtual serial
//
// SERIAL_PORT_LINUXBRIDGE    Port which connects to a Linux system via Bridge library
//
// SERIAL_PORT_HARDWARE       Hardware serial port, physical RX & TX pins.
//
// SERIAL_PORT_HARDWARE_OPEN  Hardware serial ports which are open for use.  Their RX & TX
//                            pins are NOT connected to anything by default.
#define SERIAL_PORT_MONITOR   Serial
#define SERIAL_PORT_HARDWARE  Serial

#endif

Notices in the files:
parts and their libraries:
SparkFun-DiscreteSemi: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
